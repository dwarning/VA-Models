***  NMOS and PMOS transistors PSP 103.8 (Id-Vgs, Vbs) (Id-Vds, Vgs) (Id-Vgs, T)  ***

YPSP103_VA mn1  2 1 3 4 nch
+l=0.1u
+w=1u
+sa=0.0e+00
+sb=0.0e+00
+absource=1.0e-12
+lssource=1.0e-06
+lgsource=1.0e-06
+abdrain=1.0e-12
+lsdrain=1.0e-06
+lgdrain=1.0e-06
+mult=1.0e+00

vgsn 1 0 3.5
vdsn 2 0 0.1
vssn 3 0 0
vbsn 4 0 0

YPSP103_VA mp1 22 11 33 44 pch
+l=0.1u
+w=1u
+sa=0.0e+00
+sb=0.0e+00
+absource=1.0e-12
+lssource=1.0e-06
+lgsource=1.0e-06
+abdrain=1.0e-12
+lsdrain=1.0e-06
+lgdrain=1.0e-06
+mult=1.0e+00

vgsp 11 0 -3.5
vdsp 22 0 -0.1
vssp 33 0 0
vbsp 44 0 0

* PSP modelparameters for PSP 103.3
.include ../Modelcards/psp103_nmos-2.mod
.include ../Modelcards/psp103_pmos-2.mod

* NMOS
.dc vgsn 0 1.5 0.05 vbsn 0 -1.5 -0.3
.print dc format=gnuplot vssn#branch ylabel 'Id vs. Vgs, Vbs 0 ... -1.5'
.print dc format=gnuplot abs(vssn#branch) ylog ylabel 'Id vs. Vgs, Vbs 0 ... -1.5'
*.dc vdsn 0 1.6 0.01 vgsn 0 1.6 0.2
*.print dc format=gnuplot vssn#branch ylabel 'Id vs. Vds, Vgs 0 ... 1.6'
*.dc vgsn 0 1.5 0.05 temp -40 160 40
*.print dc format=gnuplot vssn#branch ylabel 'Id vs. Vds, Temp. -40 ... 160'
*.print dc format=gnuplot abs(vssn#branch) ylog ylabel 'Id vs. Vds, Temp. -40 ... 160'

* PMOS
.dc vgsp 0 -1.5 -0.05 vbsp 0 1.5 0.3
.print dc format=gnuplot vssp#branch ylabel 'Id vs. Vgs, Vbs 0 ... 1.5'
.print dc format=gnuplot abs(vssp#branch) ylog ylabel 'Id vs. Vgs, Vbs 0 ... 1.5'
*.dc vdsp 0 -1.6 -0.01 vgsp 0 -1.6 -0.2
*.print dc format=gnuplot vssp#branch ylabel 'Id vs. Vds, Vgs 0 ... -1.6'
*.dc vgsp 0 -1.5 -0.05 temp -40 160 40
*.print dc format=gnuplot vssp#branch ylabel 'Id vs. Vds, Temp. -40 ... 160'
*.print dc format=gnuplot abs(vssp#branch) ylog ylabel 'Id vs. Vds, Temp. -40 ... 160'

.end
